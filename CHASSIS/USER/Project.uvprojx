# Keil uVision project Project.uvprojx, settings and files
target Project (5060960::V5.06 update 7 (build 960)::ARMCC)
  device: STM32F405RGTx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.3.1.1
  cpu: IRAM(0x20000000,0x00020000) IRAM2(0x10000000,0x00010000) IROM(0x08000000,0x00100000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: Project +hex
  c flags: Optim=2 uC99=1 v6Lang=3 v6LangP=3 wLevel=1
  c define: STM32F40_41xxx,USE_STDPERIPH_DRIVER,ARM_MATH_CM4
  c misc: --diag_suppress=177,1035
  c include: ..\CORE;..\HEADFILE;..\EMBEDDED\senior_struct;..\FWLIB\inc;..\FWLIB\src;..\TASK\GIMBAL_TASK\Ins;..\USER;..\BSP\can\Inc;..\BSP\sys\Inc;..\BSP\delay\Inc;..\BSP\timer\Inc;..\BSP\usart\Inc;..\TASK\RTOS\Ins;..\DSP\Inc;..\EMBEDDED\senior\CH100;..\EMBEDDED\CAN_BUS;..\USER;..\Control_Algorithm\Ins;..\TASK\BALANCE_CHASSIS\Inc;..\EMBEDDED\senior\REMOTE;..\TASK\SHOOT_TASK\17mm_SHOOT_TASK\Inc;..\EMBEDDED\USART_chassis_transmit;..\EMBEDDED\senior\VTM_REMOTE;..\EMBEDDED\senior\Auto_Shoot;..\EMBEDDED\senior\JUDGE;..\TASK\RTOS\Ins;..\TASK\CHASSIS_TASK\Inc;..\EMBEDDED\senior\CAN_CHASSIS_TRANSMIT;..\EMBEDDED\senior\JUDGE;..\EMBEDDED\senior\USART_chassis_transmit;..\EMBEDDED\senior\SUPPER_CAP;..\EMBEDDED\senior\CLIENT;..\EMBEDDED\senior\LK_TECH;..\EMBEDDED\senior\TF02;..\TASK\GM_DOUBLELOOP;..\BSP\iwdg;..\EMBEDDED\senior\REMOTE;..\BSP\iwdg;..\BSP\LED;..\EMBEDDED\DJI_MOTOR;..\USER;..\HEADFILE;..\EMBEDDED\senior\CH100;D:\keil\ARM\PACK\ARM\CMSIS-DSP\1.16.2\Include;D:\keil\ARM\PACK\ARM\CMSIS\5.9.0\CMSIS\Core\Include;.\RTE\_Template;.\RTE\_Project_;.\RTE;.\RTE\Device;..\EMBEDDED\senior\DM8009;..\Drivers\CMSIS\CMSIS-DSP\1.16.2\Include\dsp;..\Drivers;..\EMBEDDED\REMOTE
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group HEADFILE
    ./: main.c
    ../CORE/: main.h
    ../HEADFILE/: public.h
  group EMBEDDED
    ../EMBEDDED/senior_struct/: senior.c
    ../EMBEDDED/senior/CAN_CHASSIS_TRANSMIT/: can_chassis_transmit.c
    ../EMBEDDED/senior/JUDGE/: JUDGE.c
    ../EMBEDDED/senior/USART_chassis_transmit/: USART_chassis_transmit.c
    ../EMBEDDED/senior/LK_TECH/: LK_TECH.c
    ../EMBEDDED/senior/CLIENT/: client.c
    ../EMBEDDED/senior/SUPPER_CAP/: supper_cap.c
    ../EMBEDDED/senior/TF02/: TF02.c
    ../EMBEDDED/CAN_BUS/: CanBus.c
    ../EMBEDDED/DJI_MOTOR/: DJI_MOTOR.c
    ../EMBEDDED/senior/CH100/: CH100.c
    ../EMBEDDED/senior/DM8009/: DM8009.c
    ../EMBEDDED/REMOTE/: REMOTE.c
  group USER
    ./: system_stm32f4xx.c stm32f4xx_it.c
  group CORE
    ../CORE/: startup_stm32f40_41xxx.s
  group FWLIB
    ../FWLIB/src/: misc.c stm32f4xx_adc.c stm32f4xx_can.c stm32f4xx_crc.c stm32f4xx_cryp.c stm32f4xx_cryp_aes.c stm32f4xx_cryp_des.c stm32f4xx_cryp_tdes.c stm32f4xx_dac.c stm32f4xx_dbgmcu.c stm32f4xx_dcmi.c stm32f4xx_dma.c stm32f4xx_dma2d.c stm32f4xx_exti.c stm32f4xx_flash.c stm32f4xx_flash_ramfunc.c stm32f4xx_fsmc.c stm32f4xx_gpio.c stm32f4xx_hash.c stm32f4xx_hash_md5.c stm32f4xx_hash_sha1.c stm32f4xx_i2c.c stm32f4xx_iwdg.c stm32f4xx_ltdc.c stm32f4xx_pwr.c stm32f4xx_rcc.c stm32f4xx_rng.c stm32f4xx_rtc.c stm32f4xx_sai.c stm32f4xx_sdio.c stm32f4xx_spi.c stm32f4xx_syscfg.c stm32f4xx_tim.c stm32f4xx_usart.c stm32f4xx_wwdg.c
  group TASK
    ../TASK/RTOS/Src/: control_task.c
    ../TASK/CHASSIS_TASK/Src/: balance_task.c leg_task.c Mileage.c Wheel_Observe.c
    ../TASK/GM_DOUBLELOOP/: gm_doubleloop.c
  group Control_algorithm
    ../Control_Algorithm/Src/: high_pass_filter.c LESO.c low_pass_filter.c oldpid.c ramp.c
  group ReadMe
    ../ReadMe/: ReadMe.txt
  group BSP
    ../BSP/can/Src/: can.c
    ../BSP/delay/Src/: delay.c
    ../BSP/sys/Sor/: sys.c
    ../BSP/LED/: led.c
    ../BSP/timer/Src/: timer.c
    ../BSP/usart/Src/: usart.c
    ./: BSP.c
    ../BSP/iwdg/: iwdg.c
  group Drivers
    ../Drivers/: arm_copy_f32.c arm_mat_add_f32.c arm_mat_init_f32.c arm_mat_inverse_f32.c arm_mat_mult_f32.c arm_mat_sub_f32.c arm_mat_trans_f32.c
